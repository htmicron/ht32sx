# Keil uVision project Sigfox.uvprojx, settings and files
target Sigfox (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L052T8Yx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Sigfox +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L052xx,USE_HAL_DRIVER, FOR_ALL, USE_FLASH, USE_STM32L0XX_NUCLEO,  USE_SYSTICK_DELAY
  c misc: --diag_suppress=951 --wchar32
  c include: ../Inc;                                                  ../Drivers/STM32L0xx_HAL_Driver/Inc;                                                  ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                                                  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                                                  ../Drivers/CMSIS/Include;                                                  ..\Sigfox_libs\inc;                                                  ..\ST_libs\inc;                                                  ..\Drivers\S2LP_Middleware\STM32\inc;                                                  ..\ST_API\inc;                                                  ..\Drivers\Utils\STM32\inc;                                                  ..\Utils\CLI\inc;                                                  ..\Sigfox_libs\bin;                                                  ..\Utils\CLI\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: Sigfox\Sigfox.sct
  link misc: --no_strict_wchar_size
  group Application/MDK-ARM
    ./: startup_stm32l052xx.s
  group Application/User
    ../Src/: ST_Sigfox_Init.c main.c gpio.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Libraries
    ../ST_API/bin/: ST_RETRIEVER_LIB_STM32L053xx.a
    ../Sigfox_libs/bin/: SFX_LIB_V2.8.0_FDL_MON_IAR8.11_cortexM0+.a
  group Drivers/S2LP_Middleware/STM32
    ../Drivers/S2LP_Middleware/STM32/src/: S2LP_AUX_UTILS.c S2LP_AUX_EEPROM.c
    ../Drivers/S2LP_Middleware/STM32/src/FEM/: S2LP_AUX_FEM_AUTO.c
  group ST_API/src
    ../ST_API/src/: nvm_api.c rf_api.c mcu_api_stm32.c
  group Drivers/Utils/STM32
    ../Drivers/Utils/STM32/src/: SDK_UTILS_Flash.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
software components: CMSIS:CORE 5.3.0
